Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Banc Wave (sans tablette).IFC
Time: 2020-07-01T10:09:06
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: WAVE-BANC-V6-004-A
In: Default Storey
Material: AZ10S8G

# IfcBuildingElementProxy: WAVE-BANC-V6-003-A_Default
In: Default Storey
Material: AZ10S8G
PSet_Mass_Property - Mass Measure: 57.2336; Area Measure: 3.49851; Volume Measure: 0.0192706

# IfcBuildingElementProxy: WAVE-BANC-V6-006-A_Default
In: Default Storey
Material: AZ10S8G
