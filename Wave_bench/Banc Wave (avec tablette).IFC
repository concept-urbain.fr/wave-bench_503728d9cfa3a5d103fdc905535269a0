Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Banc Wave (avec tablette).IFC
Time: 2020-07-01T10:08:30
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: WAVE-BANC-V6-004-A
In: Default Storey
Material: AZ10S8G

# IfcBuildingElementProxy: WAVE-BANC-V6-002-A_Default
In: Default Storey
Material: AZ10S8G

# IfcBuildingElementProxy: WAVE-BANC-V6-003-A_Default
In: Default Storey
Material: AZ10S8G
PSet_Mass_Property - Mass Measure: 73.2498; Area Measure: 4.18366; Volume Measure: 0.0246632
